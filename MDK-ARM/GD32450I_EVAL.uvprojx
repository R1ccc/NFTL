# Keil uVision project GD32450I_EVAL.uvprojx, settings and files
target GD32450I_EVAL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F450IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32450I_EVAL +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450, DEBUG_ENABLE_SEMIHOST
  c include: ..\;..\Soft_Drive;..\..\..\Utilities;..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\..\GD32F4xx_Firmware_Library\CMSIS;..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\NFTL;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: main.c gd32f4xx_it.c systick.c gd5f1gxx.c
  group CMSIS
    ../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F450i_EVAL
    ../../../Utilities/: gd32f450i_eval.c
  group Soft_Drive
    ../Soft_Drive/: gd5f1gxx.lib
  group Startup
    ../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.1.0
